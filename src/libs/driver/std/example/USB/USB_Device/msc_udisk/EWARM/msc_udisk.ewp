# IAR project msc_udisk.ewp, settings and files
configuration USBFS (ARM, debug)
  General.OGChipSelectEditMenu: GD32F450xG GD GD32F450xG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32F450; USE_USB_FS
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\..\Firmware\CMSIS\GD\GD32F4xx\Include; ..\..\..\..\..\Firmware\GD32F4xx_standard_peripheral\Include; ..\..\..\..\..\Firmware\GD32F4xx_usb_library\device\class\msc\Include; ..\..\..\..\..\Utilities; ..\..\..\..\..\Firmware\GD32F4xx_usb_library\device\core\Include; ..\..\..\..\..\Firmware\GD32F4xx_usb_library\driver\Include; ..\..\..\..\..\Firmware\GD32F4xx_usb_library\ustd\common; ..\..\..\..\..\Firmware\GD32F4xx_usb_library\ustd\class\msc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: audio.srec
  ILINK.IlinkOutputFile: USBFS_msc_udisk.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration USBHS (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_USB_HS; USE_ULPI_PHY; GD32F450
  OBJCOPY.OOCOutputFile: msc_udisk.srec
  ILINK.IlinkOutputFile: USBHS_msc_udisk.out
  group Application
    ../src/: app.c gd32f4xx_hw.c gd32f4xx_it.c sram_msd.c usbd_storage_msd.c
  group CMSIS
    ../src/: system_gd32f4xx.c
  group Doc
    ../: readme.txt
  group GD32F4xx_EVAL
    ../../../../../Utilities/: gd32f450i_eval.c
  group GD32F4xx_StdPeriph
    ../../../../../Firmware/GD32F4xx_standard_peripheral/Source/: gd32f4xx_ctc.c gd32f4xx_dma.c gd32f4xx_exti.c gd32f4xx_gpio.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_usart.c
  group Startup
    ../../../../../Firmware/CMSIS/GD/GD32F4xx/Source/IAR/: startup_gd32f450_470.s
  group USB_Class
    ../../../../../Firmware/GD32F4xx_usb_library/device/class/msc/Source/: usbd_msc_bbb.c usbd_msc_core.c usbd_msc_scsi.c
  group USB_Device
    ../../../../../Firmware/GD32F4xx_usb_library/device/core/Source/: usbd_core.c usbd_enum.c usbd_transc.c
  group USB_Drivers
    ../../../../../Firmware/GD32F4xx_usb_library/driver/Source/: drv_usb_core.c drv_usb_dev.c drv_usbd_int.c
