# IAR project usbh_msc.ewp, settings and files
configuration USBFS (ARM, debug)
  General.OGChipSelectEditMenu: GD32F450xG GD GD32F450xG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_USB_FS; GD32F450; USE_LCD
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\..\Utilities; ..\..\..\..\..\Firmware\CMSIS\GD\GD32F4xx\Include; ..\..\..\..\..\Firmware\GD32F4xx_standard_peripheral\Include; ..\..\..\..\..\Firmware\GD32F4xx_usb_library\ustd\common; ..\..\..\..\..\Firmware\GD32F4xx_usb_library\host\core\Include; ..\..\..\..\..\Firmware\GD32F4xx_usb_library\host\class\msc\Include; ..\..\..\..\..\Firmware\GD32F4xx_usb_library\ustd\class\msc; ..\..\..\..\..\Utilities\LCD_common; ..\..\..\..\..\Firmware\GD32F4xx_usb_library\driver\Include; ..\..\..\..\..\Utilities\Third_Party\fat_fs\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: USBH_HID.srec
  ILINK.IlinkOutputFile: USBFS_usbh_msc.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration USBHS (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_USB_HS; USE_ULPI_PHY; GD32F450; USE_LCD
  ILINK.IlinkOutputFile: USBHS_usbh_msc.out
  group Application
    ../src/: gd32f4xx_it.c gd32f4xx_usb_hw.c main.c usbh_usr.c
  group CMSIS
    ../src/: system_gd32f4xx.c
  group Doc
    ../: readme.txt
  group FAT_FS
    ../../../../../Utilities/Third_Party/fat_fs/src/: ff.c ffunicode.c
  group GD32F4xx_EVAL
    ../src/: gd32f450i_eval.c lcd_font.c lcd_log.c
    ../../../../../Utilities/: gd32f450i_eval_exmc_sdram.c gd32f450i_lcd_eval.c
  group GD32F4xx_Peripherals
    ../../../../../Firmware/GD32F4xx_standard_peripheral/Source/: gd32f4xx_dma.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_gpio.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_usart.c
  group Startup
    ../../../../../Firmware/CMSIS/GD/GD32F4xx/Source/IAR/: startup_gd32f450_470.s
  group USB_Class
    ../../../../../Firmware/GD32F4xx_usb_library/host/class/msc/Source/: usbh_msc_bbb.c usbh_msc_core.c usbh_msc_fatfs.c usbh_msc_scsi.c
  group USB_Driver
    ../../../../../Firmware/GD32F4xx_usb_library/driver/Source/: drv_usb_core.c drv_usb_host.c drv_usbh_int.c
  group USB_Host
    ../../../../../Firmware/GD32F4xx_usb_library/host/core/Source/: usbh_core.c usbh_enum.c usbh_pipe.c usbh_transc.c
